v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -60 -40 0 0 {name=p1 lab=a}
C {devices/ipin.sym} -60 -10 0 0 {name=p2 lab=b}
C {devices/ipin.sym} -60 30 0 0 {name=p3 lab=VGND}
C {devices/ipin.sym} -60 70 0 0 {name=p4 lab=VPWR}
C {devices/opin.sym} 60 -40 0 0 {name=p5 lab=p[0]}
C {devices/opin.sym} 60 0 0 0 {name=p6 lab=p[1]}
C {devices/opin.sym} 60 30 0 0 {name=p7 lab=p[2]}
C {devices/opin.sym} 60 70 0 0 {name=p8 lab=p[3]}
C {devices/opin.sym} 60 110 0 0 {name=p9 lab=n[0]}
C {devices/opin.sym} 60 150 0 0 {name=p10 lab=n[1]}
C {devices/opin.sym} 60 190 0 0 {name=p11 lab=n[2]}
C {devices/opin.sym} 60 230 0 0 {name=p12 lab=n[3]}
